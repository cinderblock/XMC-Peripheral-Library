# Keil uVision project httpserver_raw.uvprojx, settings and files
target httpserver_raw (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.7.1
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: httpserver_raw
  c flags: Optim=2 wLevel=2
  c define: XMC_ETH_PHY_KSZ8081RNB
  c include: ..;..\..\..\..\..\..\ThirdPartyLibraries\lwip\src\include;..\..\..\..\..\..\ThirdPartyLibraries\lwip\port\nosys\include;..\..\..\..\..\..\ThirdPartyLibraries\lwip\port\nosys\netif
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ../: main.c ethernetif_init.c
    ../httpserver_raw/: fs.c httpd.c
  group Doc
    ../: README.txt
  group lwip
    ../../../../../../ThirdPartyLibraries/lwip/src/netif/: ethernet.c lowpan6.c
    ../../../../../../ThirdPartyLibraries/lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../../../../ThirdPartyLibraries/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
    ../../../../../../ThirdPartyLibraries/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../ThirdPartyLibraries/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../ThirdPartyLibraries/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../ThirdPartyLibraries/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../../ThirdPartyLibraries/lwip/port/nosys/: sys_arch.c
    ../../../../../../ThirdPartyLibraries/lwip/port/nosys/netif/: ethernetif.c
software components: CMSIS:CORE 4.2.0, Device:Startup 2.0.0, Device:XMClib:ETH_MAC 2.0.0, Device:XMClib:ETH_PHY 2.0.0, Device:XMClib:GPIO 2.0.0, Device:XMClib:SCU 2.0.0
