# Keil uVision project anacmp_cmp.uvprojx, settings and files
target anacmp_cmp (ARM-ADS)
  device: XMC1200-T038x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.0.0
  cpu: IROM(0x10001000,0x32000) IRAM(0x20000000,0x3FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: anacmp_cmp
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source
    ../: main.c
  group Doc
    ../: Readme.txt
  group ::Device
    C:/Keil_v5/ARM/PACK/Infineon/XMC1000_DFP/2.0.0/Device/XMClib/src/: xmc1_scu.c xmc_acmp.c xmc_common.c xmc_scu.c
    RTE/Device/XMC1200-T038x0200/: startup_XMC1200.s system_XMC1200.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:XMClib:ACMP 1.0.0, Device:XMClib:SCU 1.0.0
